v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -540 -70 -480 -70 {lab=Vp}
N -540 -70 -540 -20 {lab=Vp}
N -580 -70 -540 -70 {lab=Vp}
N -620 -20 -540 -20 {lab=Vp}
N -620 -40 -620 -20 {lab=Vp}
N -620 200 -620 220 {lab=VSS}
N -620 130 -570 130 {lab=VSS}
N -570 130 -570 200 {lab=VSS}
N -620 200 -570 200 {lab=VSS}
N -620 160 -620 200 {lab=VSS}
N -450 220 -440 220 {lab=VSS}
N -690 -70 -620 -70 {lab=VDD}
N -690 -140 -690 -70 {lab=VDD}
N -690 -140 -620 -140 {lab=VDD}
N -620 -140 -620 -100 {lab=VDD}
N -590 -140 -440 -140 {lab=VDD}
N -440 -140 -440 -100 {lab=VDD}
N -440 -70 -380 -70 {lab=VDD}
N -380 -140 -380 -70 {lab=VDD}
N -440 -140 -380 -140 {lab=VDD}
N -160 -140 -160 -70 {lab=Vp}
N -100 -120 -100 -40 {lab=VDD}
N 120 -130 120 -60 {lab=Vp}
N 180 -110 180 -30 {lab=VDD}
N 400 -130 400 -60 {lab=Vp}
N 460 -110 460 -30 {lab=VDD}
N -100 40 -100 110 {lab=VSS}
N -160 60 -160 140 {lab=Vn}
N 180 50 180 120 {lab=VSS}
N 120 70 120 150 {lab=Vn}
N 460 50 460 120 {lab=VSS}
N 400 70 400 150 {lab=Vn}
N -590 -190 -590 -140 {lab=VDD}
N -620 -140 -590 -140 {lab=VDD}
N -590 220 -590 250 {lab=VSS}
N -620 220 -590 220 {lab=VSS}
N -730 130 -660 130 {lab=Vin}
N -40 20 -40 40 {lab=#net1}
N -40 -30 -40 -20 {lab=#net2}
N 240 -30 240 -10 {lab=#net3}
N 240 30 240 40 {lab=#net4}
N -390 -220 -360 -220 {lab=Vin}
N -400 -280 -370 -280 {lab=VIP}
N -400 -310 -370 -310 {lab=VSS}
N -400 -350 -370 -350 {lab=VDD}
N -400 -250 -370 -250 {lab=VIN}
N -440 190 -440 220 {lab=VSS}
N -440 140 -410 140 {lab=VSS}
N -440 190 -410 190 {lab=VSS}
N -410 140 -410 190 {lab=VSS}
N -440 170 -440 190 {lab=VSS}
N -440 100 -440 110 {lab=Vn}
N -510 140 -480 140 {lab=Vn}
N -510 100 -510 140 {lab=Vn}
N -510 100 -440 100 {lab=Vn}
N -440 -40 -440 100 {lab=Vn}
N -620 -20 -620 100 {lab=Vp}
N -40 -30 -0 -30 {lab=#net2}
N 0 -30 0 40 {lab=#net2}
N 0 40 80 40 {lab=#net2}
N -40 40 -10 40 {lab=#net1}
N -10 -10 -10 40 {lab=#net1}
N -10 -10 80 -10 {lab=#net1}
N 80 -30 80 -10 {lab=#net1}
N 240 -30 320 -30 {lab=#net3}
N 320 -30 320 40 {lab=#net3}
N 320 40 360 40 {lab=#net3}
N 240 40 300 40 {lab=#net4}
N 300 30 300 40 {lab=#net4}
N 300 30 340 30 {lab=#net4}
N 340 -20 340 30 {lab=#net4}
N 340 -20 360 -20 {lab=#net4}
N 360 -30 360 -20 {lab=#net4}
N 2060 -340 2060 -320 {lab=VDD}
N 2060 -290 2090 -290 {lab=VDD}
N 2090 -340 2090 -290 {lab=VDD}
N 2060 -340 2090 -340 {lab=VDD}
N 2060 -380 2060 -340 {lab=VDD}
N 2100 -180 2100 -120 {lab=VSS}
N 2060 -120 2100 -120 {lab=VSS}
N 2060 -120 2060 -70 {lab=VSS}
N -270 -40 -200 -40 {lab=#net5}
N -270 -190 -270 -40 {lab=#net5}
N -260 30 -200 30 {lab=#net6}
N -260 30 -260 190 {lab=#net6}
N 2020 -290 2020 -240 {lab=#net7}
N 1620 -330 1620 -310 {lab=VDD}
N 1620 -280 1650 -280 {lab=VDD}
N 1650 -330 1650 -280 {lab=VDD}
N 1620 -330 1650 -330 {lab=VDD}
N 1620 -370 1620 -330 {lab=VDD}
N 1620 -170 1660 -170 {lab=VSS}
N 1660 -170 1660 -110 {lab=VSS}
N 1620 -110 1660 -110 {lab=VSS}
N 1620 -140 1620 -110 {lab=VSS}
N 1620 -110 1620 -60 {lab=VSS}
N 1580 -280 1580 -230 {lab=#net8}
N 1580 -230 1580 -170 {lab=#net8}
N 2300 -330 2300 -310 {lab=VDD}
N 2300 -280 2330 -280 {lab=VDD}
N 2330 -330 2330 -280 {lab=VDD}
N 2300 -330 2330 -330 {lab=VDD}
N 2300 -370 2300 -330 {lab=VDD}
N 2300 -170 2340 -170 {lab=VSS}
N 2340 -170 2340 -110 {lab=VSS}
N 2300 -110 2340 -110 {lab=VSS}
N 2300 -140 2300 -110 {lab=VSS}
N 2060 -260 2060 -230 {lab=#net9}
N 2300 -220 2300 -200 {lab=VIP}
N 2020 -240 2020 -180 {lab=#net7}
N 2060 -180 2100 -180 {lab=VSS}
N 2060 -230 2060 -210 {lab=#net9}
N 2060 -150 2060 -120 {lab=VSS}
N -260 190 1110 190 {lab=#net6}
N 2060 -230 2240 -230 {lab=#net9}
N 2300 -110 2300 -60 {lab=VSS}
N 2240 -280 2260 -280 {lab=#net9}
N 2240 -230 2240 -170 {lab=#net9}
N 2240 -170 2260 -170 {lab=#net9}
N 2240 -280 2240 -230 {lab=#net9}
N 2300 -220 2480 -220 {lab=VIP}
N 2300 -250 2300 -220 {lab=VIP}
N 710 -140 710 -70 {lab=Vp}
N 770 -120 770 -40 {lab=VDD}
N 990 -140 990 -70 {lab=Vp}
N 1050 -120 1050 -40 {lab=VDD}
N 770 40 770 110 {lab=VSS}
N 710 60 710 140 {lab=Vn}
N 1050 40 1050 110 {lab=VSS}
N 990 60 990 140 {lab=Vn}
N 830 -40 830 -20 {lab=#net10}
N 830 20 830 30 {lab=#net11}
N 590 30 670 30 {lab=#net12}
N 670 -40 670 10 {lab=#net13}
N 830 -40 910 -40 {lab=#net10}
N 910 -40 910 30 {lab=#net10}
N 910 30 950 30 {lab=#net10}
N 830 30 890 30 {lab=#net11}
N 890 20 890 30 {lab=#net11}
N 890 20 930 20 {lab=#net11}
N 930 -30 930 20 {lab=#net11}
N 930 -30 950 -30 {lab=#net11}
N 950 -40 950 -30 {lab=#net11}
N -270 -190 1110 -190 {lab=#net5}
N 520 -10 590 -10 {lab=#net12}
N 590 -10 590 30 {lab=#net12}
N 520 30 560 30 {lab=#net13}
N 560 10 560 30 {lab=#net13}
N 560 10 670 10 {lab=#net13}
N 1110 -190 1110 -20 {lab=#net5}
N 1110 20 1110 190 {lab=#net6}
N 1390 -340 1390 -320 {lab=VDD}
N 1390 -290 1420 -290 {lab=VDD}
N 1420 -340 1420 -290 {lab=VDD}
N 1390 -340 1420 -340 {lab=VDD}
N 1390 -380 1390 -340 {lab=VDD}
N 1390 -180 1430 -180 {lab=VSS}
N 1430 -180 1430 -120 {lab=VSS}
N 1390 -120 1430 -120 {lab=VSS}
N 1390 -150 1390 -120 {lab=VSS}
N 1390 -120 1390 -70 {lab=VSS}
N 1350 -290 1350 -240 {lab=#net5}
N 1350 -240 1350 -180 {lab=#net5}
N 1290 -240 1350 -240 {lab=#net5}
N 1390 -230 1390 -210 {lab=#net8}
N 1860 -340 1860 -320 {lab=VDD}
N 1860 -290 1890 -290 {lab=VDD}
N 1890 -340 1890 -290 {lab=VDD}
N 1860 -340 1890 -340 {lab=VDD}
N 1860 -380 1860 -340 {lab=VDD}
N 1860 -180 1900 -180 {lab=VSS}
N 1900 -180 1900 -120 {lab=VSS}
N 1860 -120 1900 -120 {lab=VSS}
N 1860 -150 1860 -120 {lab=VSS}
N 1860 -120 1860 -70 {lab=VSS}
N 1820 -290 1820 -240 {lab=#net14}
N 1820 -240 1820 -180 {lab=#net14}
N 1860 -240 1860 -210 {lab=#net7}
N 1390 -230 1580 -230 {lab=#net8}
N 1390 -260 1390 -230 {lab=#net8}
N 1620 -240 1820 -240 {lab=#net14}
N 1620 -240 1620 -200 {lab=#net14}
N 1620 -250 1620 -240 {lab=#net14}
N 1860 -240 2020 -240 {lab=#net7}
N 1860 -260 1860 -240 {lab=#net7}
N 1110 -190 1290 -190 {lab=#net5}
N 1290 -240 1290 -190 {lab=#net5}
N -450 220 -450 250 {lab=VSS}
N -590 220 -450 220 {lab=VSS}
N 2060 130 2060 150 {lab=VDD}
N 2060 180 2090 180 {lab=VDD}
N 2090 130 2090 180 {lab=VDD}
N 2060 130 2090 130 {lab=VDD}
N 2060 90 2060 130 {lab=VDD}
N 2100 290 2100 350 {lab=VSS}
N 2060 350 2100 350 {lab=VSS}
N 2060 350 2060 400 {lab=VSS}
N 2020 180 2020 230 {lab=#net15}
N 1620 140 1620 160 {lab=VDD}
N 1620 190 1650 190 {lab=VDD}
N 1650 140 1650 190 {lab=VDD}
N 1620 140 1650 140 {lab=VDD}
N 1620 100 1620 140 {lab=VDD}
N 1620 300 1660 300 {lab=#net16}
N 1660 300 1660 360 {lab=#net16}
N 1620 360 1660 360 {lab=#net16}
N 1620 330 1620 360 {lab=#net16}
N 1620 360 1620 410 {lab=#net16}
N 1580 190 1580 240 {lab=#net17}
N 1580 240 1580 300 {lab=#net17}
N 2300 140 2300 160 {lab=VDD}
N 2300 190 2330 190 {lab=VDD}
N 2330 140 2330 190 {lab=VDD}
N 2300 140 2330 140 {lab=VDD}
N 2300 100 2300 140 {lab=VDD}
N 2300 300 2340 300 {lab=VSS}
N 2340 300 2340 360 {lab=VSS}
N 2300 360 2340 360 {lab=VSS}
N 2300 330 2300 360 {lab=VSS}
N 2060 210 2060 240 {lab=#net18}
N 2300 250 2300 270 {lab=VIN}
N 2020 230 2020 290 {lab=#net15}
N 2060 290 2100 290 {lab=VSS}
N 2060 240 2060 260 {lab=#net18}
N 2060 320 2060 350 {lab=VSS}
N 2060 240 2240 240 {lab=#net18}
N 2300 360 2300 410 {lab=VSS}
N 2240 190 2260 190 {lab=#net18}
N 2240 240 2240 300 {lab=#net18}
N 2240 300 2260 300 {lab=#net18}
N 2240 190 2240 240 {lab=#net18}
N 2300 250 2480 250 {lab=VIN}
N 2300 220 2300 250 {lab=VIN}
N 1390 130 1390 150 {lab=VDD}
N 1390 180 1420 180 {lab=VDD}
N 1420 130 1420 180 {lab=VDD}
N 1390 130 1420 130 {lab=VDD}
N 1390 90 1390 130 {lab=VDD}
N 1390 290 1430 290 {lab=#net19}
N 1430 290 1430 350 {lab=#net19}
N 1390 350 1430 350 {lab=#net19}
N 1390 320 1390 350 {lab=#net19}
N 1390 350 1390 400 {lab=#net19}
N 1350 180 1350 230 {lab=#net6}
N 1350 230 1350 290 {lab=#net6}
N 1290 230 1350 230 {lab=#net6}
N 1390 240 1390 260 {lab=#net17}
N 1860 130 1860 150 {lab=VDD}
N 1860 180 1890 180 {lab=VDD}
N 1890 130 1890 180 {lab=VDD}
N 1860 130 1890 130 {lab=VDD}
N 1860 90 1860 130 {lab=VDD}
N 1860 290 1900 290 {lab=VSS}
N 1900 290 1900 350 {lab=VSS}
N 1860 350 1900 350 {lab=VSS}
N 1860 320 1860 350 {lab=VSS}
N 1860 350 1860 400 {lab=VSS}
N 1820 180 1820 230 {lab=#net20}
N 1820 230 1820 290 {lab=#net20}
N 1860 230 1860 260 {lab=#net15}
N 1390 240 1580 240 {lab=#net17}
N 1390 210 1390 240 {lab=#net17}
N 1620 230 1820 230 {lab=#net20}
N 1620 230 1620 270 {lab=#net20}
N 1620 220 1620 230 {lab=#net20}
N 1860 230 2020 230 {lab=#net15}
N 1860 210 1860 230 {lab=#net15}
N 1110 190 1290 190 {lab=#net6}
N 1290 190 1290 230 {lab=#net6}
N 900 460 960 460 {lab=#net21}
N 960 460 960 500 {lab=#net21}
N 990 440 990 460 {lab=#net22}
N 870 440 990 440 {lab=#net22}
N 870 440 870 500 {lab=#net22}
N 900 500 940 500 {lab=VSS}
N 990 500 1040 500 {lab=VDD}
N 940 500 940 600 {lab=VSS}
N 1110 460 1170 460 {lab=#net23}
N 1170 460 1170 500 {lab=#net23}
N 1200 440 1200 460 {lab=#net24}
N 1080 440 1200 440 {lab=#net24}
N 1080 440 1080 500 {lab=#net24}
N 1110 500 1150 500 {lab=VSS}
N 1200 500 1250 500 {lab=VDD}
N 1150 500 1150 600 {lab=VSS}
N 690 460 750 460 {lab=#net25}
N 750 460 750 500 {lab=#net25}
N 780 440 780 460 {lab=#net26}
N 660 440 780 440 {lab=#net26}
N 660 440 660 500 {lab=#net26}
N 690 500 730 500 {lab=VSS}
N 780 500 830 500 {lab=VDD}
N 730 500 730 600 {lab=VSS}
N 830 360 830 500 {lab=VDD}
N 1040 360 1040 500 {lab=VDD}
N 1250 360 1250 500 {lab=VDD}
N 730 600 940 600 {lab=VSS}
N 940 600 1150 600 {lab=VSS}
N 830 360 1040 360 {lab=VDD}
N 1040 360 1250 360 {lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} -460 140 2 1 {name=M2
l=0.13u
w=10.0u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} -460 -70 0 0 {name=M3
L=0.13u
W=10.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} -600 -70 0 1 {name=M4
L=0.13u
W=10.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -160 -140 1 0 {name=p1 sig_type=std_logic lab=Vp}
C {lab_pin.sym} -100 -120 1 0 {name=p2 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 120 -130 1 0 {name=p3 sig_type=std_logic lab=Vp}
C {lab_pin.sym} 180 -110 1 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 400 -130 1 0 {name=p5 sig_type=std_logic lab=Vp}
C {lab_pin.sym} -520 -70 1 0 {name=p7 sig_type=std_logic lab=Vp}
C {lab_pin.sym} -160 140 3 0 {name=p8 sig_type=std_logic lab=Vn}
C {lab_pin.sym} -530 220 3 0 {name=p10 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -520 -140 1 0 {name=p11 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -100 110 3 0 {name=p13 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 120 150 3 0 {name=p14 sig_type=std_logic lab=Vn}
C {lab_pin.sym} 180 120 3 0 {name=p15 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 400 150 3 0 {name=p16 sig_type=std_logic lab=Vn
}
C {lab_pin.sym} 460 120 3 0 {name=p17 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2480 -220 2 0 {name=p22 sig_type=std_logic lab=VIP}
C {sg13g2_pr/bondpad.sym} 2420 -260 0 0 {name=VIP
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -590 -230 0 0 {name=X8
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -770 130 3 0 {name=VCTRL
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {devices/code_shown.sym} 160 250 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.include diodes.lib
.include sg13g2_bondpad.lib
.lib $::SG13G2_MODELS/cornerRES.lib res_typ_stat
.lib cornerMOSlv.lib mos_ff
.lib $::SG13G2_MODELS/cornerCAP.lib cap_wcs
"}
C {devices/code_shown.sym} -160 240 0 0 {name=NGSPICE only_toplevel=true 
value="
.param temp=127
.control
save all 
tran 50p 100n
write tran_VCO.raw
.endc
"}
C {iopin.sym} -370 -350 0 0 {name=p25 lab=VDD}
C {iopin.sym} -370 -310 0 0 {name=p26 lab=VSS}
C {ipin.sym} -390 -220 0 0 {name=p28 lab=Vin}
C {opin.sym} -370 -250 0 0 {name=p30 lab=VIN
}
C {lab_pin.sym} -400 -280 0 0 {name=p31 sig_type=std_logic lab=VIP}
C {lab_pin.sym} -400 -250 0 0 {name=p32 sig_type=std_logic lab=VIN}
C {lab_pin.sym} -400 -350 0 0 {name=p33 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -400 -310 0 0 {name=p34 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -700 130 1 0 {name=p35 sig_type=std_logic lab=Vin}
C {lab_pin.sym} -360 -220 2 0 {name=p36 sig_type=std_logic lab=Vin}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} -640 130 2 1 {name=M1
l=0.13u
w=10.0u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} -480 100 1 0 {name=p37 sig_type=std_logic lab=Vn}
C {lab_pin.sym} 460 -110 1 0 {name=p12 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2060 -380 1 0 {name=p24 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2040 -180 2 1 {name=M8
l=0.13u
w=3.2u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2040 -290 0 0 {name=M9
L=0.13u
W=6.4u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2060 -70 3 0 {name=p6 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1620 -370 1 0 {name=p20 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1600 -170 0 0 {name=M11
l=0.13u
w=1.6u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1600 -280 0 0 {name=M12
L=0.13u
W=3.2u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1620 -60 3 0 {name=p21 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2300 -370 1 0 {name=p43 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2280 -170 2 1 {name=M23
l=0.13u
w=3.2u
ng=6
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2280 -280 0 0 {name=M24
L=0.13u
W=6.4u
ng=6
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2300 -60 3 0 {name=p44 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 710 -140 1 0 {name=p9 sig_type=std_logic lab=Vp}
C {lab_pin.sym} 770 -120 1 0 {name=p18 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 990 -140 1 0 {name=p19 sig_type=std_logic lab=Vp}
C {lab_pin.sym} 710 140 3 0 {name=p23 sig_type=std_logic lab=Vn}
C {lab_pin.sym} 770 110 3 0 {name=p29 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 990 140 3 0 {name=p38 sig_type=std_logic lab=Vn
}
C {lab_pin.sym} 1050 110 3 0 {name=p39 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1050 -120 1 0 {name=p40 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1390 -380 1 0 {name=p41 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1370 -180 0 0 {name=M5
l=0.13u
w=0.4u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1370 -290 0 0 {name=M6
L=0.13u
W=0.80u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1390 -70 3 0 {name=p42 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1860 -380 1 0 {name=p45 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1840 -180 0 0 {name=M7
l=0.13u
w=3.2u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1840 -290 0 0 {name=M10
L=0.13u
W=6.4u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1860 -70 3 0 {name=p46 sig_type=std_logic lab=VSS}
C {sg13g2_pr/bondpad.sym} -590 290 2 0 {name=GND
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -450 290 2 0 {name=GND1
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 2420 210 0 0 {name=VIN
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {lab_pin.sym} 2060 90 1 0 {name=p49 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2040 290 2 1 {name=M13
l=0.13u
w=3.2u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2040 180 0 0 {name=M14
L=0.13u
W=6.4u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2060 400 3 0 {name=p50 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1620 100 1 0 {name=p51 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1600 300 0 0 {name=M15
l=0.13u
w=1.6u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1600 190 0 0 {name=M16
L=0.13u
W=3.2u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2300 100 1 0 {name=p53 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2280 300 2 1 {name=M17
l=0.13u
w=3.2u
ng=6
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2280 190 0 0 {name=M18
L=0.13u
W=6.4u
ng=6
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2300 410 3 0 {name=p54 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1390 90 1 0 {name=p55 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1370 290 0 0 {name=M19
l=0.13u
w=0.4u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1370 180 0 0 {name=M20
L=0.13u
W=0.80u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1860 90 1 0 {name=p57 sig_type=std_logic lab=VDD}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1840 290 0 0 {name=M21
l=0.13u
w=3.2u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1840 180 0 0 {name=M22
L=0.13u
W=6.4u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1860 400 3 0 {name=p58 sig_type=std_logic lab=VSS}
C {sg13g2_pr/bondpad.sym} 1390 440 2 0 {name=GND2
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 1620 450 2 0 {name=GND3
model=bondpad
spiceprefix=X
size=60u
shape=0
padtype=0
}
C {lab_pin.sym} 2480 250 2 0 {name=p62 sig_type=std_logic lab=VIN
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 900 480 1 0 {name=M26
l=0.13u
w=250u
ng=25
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 990 480 1 0 {name=M25
L=0.13u
W=250u
ng=25
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1110 480 1 0 {name=M27
l=0.13u
w=250u
ng=25
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1200 480 1 0 {name=M28
L=0.13u
W=250u
ng=25
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 690 480 1 0 {name=M29
l=0.13u
w=250u
ng=25
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 780 480 1 0 {name=M30
L=0.13u
W=250u
ng=25
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1000 360 1 0 {name=p69 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 980 600 3 0 {name=p70 sig_type=std_logic lab=VSS}
C {opin.sym} -370 -280 0 0 {name=p27 lab=VIP
}
C {vcocelltb.sym} -50 0 0 0 {name=x1}
C {vcocelltb.sym} 230 10 0 0 {name=x2}
C {vcocelltb.sym} 510 10 0 0 {name=x3}
C {vcocelltb.sym} 820 0 0 0 {name=x4}
C {vcocelltb.sym} 1100 0 0 0 {name=x5}
